options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: chirpGui
    output_language: python
    title: Chirp Function
  states: {}

blocks:
- name: numSamples
  id: variable
  parameters:
    value: int(samp_rate / rep_Hz)
  states: {}
- name: periods
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rep_Hz
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: start_Hz
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: stop_Hz
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: chirpLinear3.iq
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: numSamples
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: chirp.chirp(samp_rate, rep_Hz, start_Hz, stop_Hz, periods)
    vlen: numSamples
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: numSamples
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: junk.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: samp_rate
  states: {state: disabled}
- name: import_0_0
  id: import
  parameters:
    imports: import chirp
  states: {}

connections:
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_throttle_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_float_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
